/*@!Encoding:1252*/

variables
{

}
