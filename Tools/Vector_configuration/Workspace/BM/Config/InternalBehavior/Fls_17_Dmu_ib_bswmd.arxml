<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-2.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="33022ff3-f082-4548-ab3c-90793765f2d3">
      <SHORT-NAME>AURIX2G</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="7e118c10-0a18-49f2-9978-33759fe5e7c2">
          <SHORT-NAME>EcucDefs</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="591d4d8d-29d7-4572-84b5-e1addc66f7ad">
              <SHORT-NAME>Fls_ib_bswmd</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8cb0aab9-7120-4526-ad9c-9f363bdd4e25">
                  <SHORT-NAME>BswModuleDescriptions</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
