<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="e76d7047-39cd-40c7-836e-4c69402e9669">
          <SHORT-NAME>NvM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="25c0c8a7-55d3-42e1-80f1-d916b908cb40">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="49a9260e-eeba-4ae0-a31d-87812ecace91">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="fbf354de-2495-49db-9201-b89a80d2953d">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="113b8aa5-cef3-4b58-9e79-7c637320b15c">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="fd0479b1-e5da-4b4a-bc0f-df2629c1e52c">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
