<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-3-0.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="6b25073c-e1ce-40c2-a6bd-7fa4f5df5217">
          <SHORT-NAME>KeyM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="f9dc71c9-71e8-4a91-a3b7-3065db23e256">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="e78ee0ac-1924-432e-aba6-1db1585182c8">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="87b9c01f-e4d4-4c4d-91f9-f44c9b414e94">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5c8b3501-a1f3-40d1-bffa-8d41bcf916ad">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
