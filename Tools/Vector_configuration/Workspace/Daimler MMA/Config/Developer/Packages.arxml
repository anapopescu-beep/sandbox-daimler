<?xml version="1.0" encoding="utf-8"?>
<!--This file was saved with a tool from Vector Informatik GmbH-->
<AUTOSAR xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_00049.xsd" xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="24A5E51EDE2E3A289C3A332382CEA552">
      <SHORT-NAME>AUTOSAR_Platform</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="122FE2002CF235EB84D8CDC4233B5E13">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="75B6418BF5013434B6592C3AA60E4F5F">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="37ECBB69-B290-4FF4-80A2-18BCB1906529">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="BA8D9F4ACC62301798DB79563F805CA1">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="ff55d029-386d-43a2-b3c2-dfef4c7a5e36">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="13d3e52b-f079-430b-9048-35c45be0d231">
          <SHORT-NAME>KeyM_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c1608672-8fb1-45a6-b986-9cc31c369c6f">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="70234323-4F24-4C53-896B-2B902F11B269">
          <SHORT-NAME>AdcIf</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="17535712-D05B-4C89-83F9-EE06DED495AE">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="1BBBC0D1-3151-4D72-A4B6-00E191CC1B3A">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="733E2DC1-12A4-43DD-8887-97FA10C1C5B8">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="47F89F24-1415-40E2-9F44-965B8B1FA6CC">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0B7405D5-3689-43D8-BA24-2A852CEFC004">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5A21A69A-4B17-4617-A83E-FC08AC12CB1D">
          <SHORT-NAME>PwmIf</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="A3095CE4-A718-449B-8420-0A1C10A06ACA">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="11F0D53B-AD70-4819-82A3-3A34F1D06846">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="95147B7C-DC68-4493-8B65-3628EDDEE213">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2DCDA143-902C-47FA-953F-6275A193CBF5">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="EE8624BA-B37B-4B86-8B02-70186636482E">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2CB43E06-4F17-41A0-94F5-544DCD58FE6F">
          <SHORT-NAME>SBC</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="6D24E192-A4F2-49CF-B5D2-7EF62EF33E88">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="50EB61E3-8878-4B30-B0E9-CDCE049C0E33">
              <SHORT-NAME>DataTypes</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="BAC308EC-7EDC-439B-B8D5-8B91AFDE3847">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4687ACDD-9DFA-419B-A017-3B1E2D3A68FE">
                  <SHORT-NAME>DataConstrs</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D65330C5-E27A-4C77-99BC-22A714DAC590">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C85B6A036A14366E9183B76CC88F53D5">
      <SHORT-NAME>EcuInstances</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="61B7079595033DF0B1326105CEA073CD">
      <SHORT-NAME>Systems</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="20D1BECDBCE0307E85A8817D8C38C408">
      <SHORT-NAME>SystemSignals</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="8702BD10B6FB3E70B760812622577A73">
      <SHORT-NAME>SystemSignalGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="05AAC3703F7D38B6BDCC4ADCBF370CF0">
      <SHORT-NAME>Pdus</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="947D259B152833508AA380A2B3165A48">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7C5028F22B553E8A9A0DA54559C4D26B">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BB0F59577C453896B92BDC38E1000086">
      <SHORT-NAME>ISignals</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="E10E2F13E57330BDA71EAF4C03B8F65B">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="7772CA57CB3536578DFC36E4E6CC9FE0">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="47E391EF935933CD8513614BD0633FBB">
                  <SHORT-NAME>ADAS_POSITION_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A52EA5365D253EA782C42296EDC4974C">
                  <SHORT-NAME>Bckl_Sw_Fx_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7B5F04A3511B3235B16129C2CA49B980">
                  <SHORT-NAME>BeltAdj_FL_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="1907382B612B3E83BFB330130BB96207">
                  <SHORT-NAME>BeltAdj_FR_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C6C93ED57DBB3DEE81D7AEE284E1A78D">
                  <SHORT-NAME>BeltAdj_UI_Set_Rq_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AB7D30B28E8A39A1A9542E23A6A6CDCF">
                  <SHORT-NAME>BeltHdOvr_FL_State_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="219BE93AD41C30EC967A097FF8F139B1">
                  <SHORT-NAME>CLkS_Dr_State_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AC5D60B510C9367888043C9BB45699AB">
                  <SHORT-NAME>Develop8_Rq_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2021F4C9317D31648E0E77EB8F29977E">
                  <SHORT-NAME>Develop8_Rs_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="BCB4FA3F36F232FAA4F5D3DC2C6336FE">
                  <SHORT-NAME>DI_OdoSpeedometer_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D9F6D2F6E8A038FFA4A61DCC705470AB">
                  <SHORT-NAME>DIAG_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7999C82C36F63C84A8F08D029FD301A4">
                  <SHORT-NAME>DPC_Md_Rq_ESP_d1_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A1FA508C5656316E95044F55890929CB">
                  <SHORT-NAME>ECU_Stat_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9B92BE3415C4325385E9DE7467E7FFE1">
                  <SHORT-NAME>ELC_Lvr_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="00F6228A7605359A9CA51F3E993C2079">
                  <SHORT-NAME>EVC_CfgList_01_08_Pr5_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="457F17F3462131A694BE83A39BBB0390">
                  <SHORT-NAME>Ign_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4270C10FDA1E3B71BAEC6696793702C7">
                  <SHORT-NAME>Impact2_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="4DC1095E6AFA373B8AC8E3ABAC16EDA2">
                  <SHORT-NAME>Impact3_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0444486FE2A23F03A9126D11A1AAE1D1">
                  <SHORT-NAME>Meas8_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2ED22350A5D43BE5ADF490F7BFD310F1">
                  <SHORT-NAME>NM_Dummy_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="98903D80934330C8B943DDA8A78347DA">
                  <SHORT-NAME>NM_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5331C8B07AF533C39C7DD01D4C6D5B98">
                  <SHORT-NAME>NTG_Master_Navi_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A6324C1CD51C30AD9497E306B49EEF19">
                  <SHORT-NAME>PN14_Master_Stat1_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3FCD6A2F9157335980740E2488A883B2">
                  <SHORT-NAME>PresfAct_Adj_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DD8C0176EB5734ED9B1574F5D9A1B622">
                  <SHORT-NAME>PT4_PTCoor4_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2A49327160D33B4584FD192254EFC1EF">
                  <SHORT-NAME>PT4_PTCoor9_d1_BC_F_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="648C68440E0C3454BC413801A87660FF">
                  <SHORT-NAME>PT4_PTCoor_DrvPosn_Gear_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="470A106BF6DF37E5B76F69A195C889B8">
                  <SHORT-NAME>RBTM_FL_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="56840E7A06BE30A0A072847AD7E82719">
                  <SHORT-NAME>RBTM_FL_Tens_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E3775985C84C3B25A60F24C66A391081">
                  <SHORT-NAME>RBTM_FR_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="03B55BD1041A3188B9854BC1D0A73B53">
                  <SHORT-NAME>ROE_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="98AA046ECBB33748880F1FD11C5D9856">
                  <SHORT-NAME>SBeltTens_SP_Lvl_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C00BD39C660D30B595426679CEABA25C">
                  <SHORT-NAME>VSS_TP_Auth_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="67E5A0AB96A638C58C84EB6474E8386A">
                  <SHORT-NAME>VSS_TP_RealTmOffset_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C63A7A17CF6C39A0BA999AEB8DA69284">
                  <SHORT-NAME>VSS_TP_SecTickCount_Lvl2_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D0D91C21106534299B83E7B691AEA966">
                  <SHORT-NAME>VSS_TP_SharedSecret_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FCB1725D68C038018C01C6080CDE9AC7">
                  <SHORT-NAME>VSS_TP_VIN_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D4E001502A7C3B00BB3C615560640475">
                  <SHORT-NAME>ADAS_PREDICTION_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6F2934FCA04636F489099CFA29CB329F">
                  <SHORT-NAME>ADAS_PROFILE_SHORT_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AD989EC3BA4531668FC943C1E6A7F203">
                  <SHORT-NAME>BeltHdOvr_FR_State_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="DB964318A2DC3E07B751DCC30595AF52">
                  <SHORT-NAME>Develop8_Rq_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D5D24FEC3BBC33F2918879F2322BA4E7">
                  <SHORT-NAME>Develop8_Rs_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="585AA3F35498381DBE9EE471F3F2BD19">
                  <SHORT-NAME>ECU_Stat_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="FC7577796DFD399F8564159080797288">
                  <SHORT-NAME>Meas8_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AAD16F6FD8CD3BD98B52CA82F28AA17D">
                  <SHORT-NAME>NM_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5BC3FB3FA7443BCEAC5C9C6139F94C18">
                  <SHORT-NAME>RBTM_FR_Tens_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="35B5E14F009C3C3E95E2EFB59F864E16">
                  <SHORT-NAME>ROE_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3CFB3F42678134AE814BA6B68ABFF670">
      <SHORT-NAME>DataTransformations</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B1104BE6F2A83A7D8BF76A6E0B06FC28">
      <SHORT-NAME>ISignalGroups</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="DDC047F106A53BA2A8D607E10FEAEE3B">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="B67DCE00C5B53F7EB75C37580998E8D8">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="30A3D499620A37FF82FD726DDAADB444">
                  <SHORT-NAME>ADAS_POSITION_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C9DC7E157E6C3178B5B52267F482D9E0">
                  <SHORT-NAME>Bckl_Sw_Fx_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2A5C0B03E4923B6CB74DD2503E723BB5">
                  <SHORT-NAME>CLkS_Dr_State_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="5FE2DD31394B359683C998AFEFA4A06A">
                  <SHORT-NAME>Develop8_Rq_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2770387924983CFDAE3F5F0D407F601C">
                  <SHORT-NAME>Develop8_Rs_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="69171C9089AF30EEAA6B456B9A97A4C9">
                  <SHORT-NAME>DI_OdoSpeedometer_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7306B3810EB9398CADCADC4DDC9639F9">
                  <SHORT-NAME>DPC_Md_Rq_ESP_d1_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6557BEACB1FB389EAB9E1961B7792BAF">
                  <SHORT-NAME>ELC_Lvr_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="B53FDCAE5CB63A4DB6AB0DE00C20F327">
                  <SHORT-NAME>EVC_CfgList_01_08_Pr5_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="95137BA1FDA73586B306F90EE8076996">
                  <SHORT-NAME>Ign_Stat_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A8AB665CF488370F8B2BAC27346A574A">
                  <SHORT-NAME>Impact2_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="030DB860951D3321AEEB50585A4ECD38">
                  <SHORT-NAME>Impact3_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6F0A68FFE5C03858924B842846EF3739">
                  <SHORT-NAME>Meas8_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C714D24BFD8D355BAE8E334DC2A09A70">
                  <SHORT-NAME>PresfAct_Adj_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="29B120ADA8563DC3B48253983F95F8D4">
                  <SHORT-NAME>PT4_PTCoor4_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="30C5C5605A26379D930002C43459184F">
                  <SHORT-NAME>PT4_PTCoor9_d1_BC_F_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E004B4C91BFC3C4790875346ED97B6C1">
                  <SHORT-NAME>PT4_PTCoor_DrvPosn_Gear_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="66AFF282EC4A349C8F83D240C46016C0">
                  <SHORT-NAME>ROE_RBTM_FL_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="99367F57D6043590950F655CBBE5E701">
                  <SHORT-NAME>SBeltTens_SP_Lvl_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="03AD80F5DDDD30BCA7DA32143BBF4260">
                  <SHORT-NAME>VSS_TP_Auth_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="59C873D4256D3706ACDF4356D3184459">
                  <SHORT-NAME>VSS_TP_RealTmOffset_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2325FE5B9A6D30EFBB4D552CD6A05DED">
                  <SHORT-NAME>VSS_TP_SecTickCount_Lvl2_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C35C65F0D7B936B4B9CADEA09E4C6453">
                  <SHORT-NAME>VSS_TP_SharedSecret_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E3BEB9A0CE10320690E9AC75E2F2CEAE">
                  <SHORT-NAME>VSS_TP_VIN_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0AD304F000483E79A9B261469D0DD0D1">
                  <SHORT-NAME>ADAS_PREDICTION_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A3E382EC9F4F3050952F3D47DB49219C">
                  <SHORT-NAME>ADAS_PROFILE_SHORT_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="AFE905D64AED36EFA1F460CABE8DC5EB">
                  <SHORT-NAME>Develop8_Rq_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="3C9014462C363DFFAB475DA49951E1EE">
                  <SHORT-NAME>Develop8_Rs_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="D24B8F37D37D3A4BA4B48BF0E7B1003A">
                  <SHORT-NAME>Meas8_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7DC205227C543CBDA06230E4E10ABE1F">
                  <SHORT-NAME>ROE_RBTM_FR_ST3</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="53BDF5E1DD26313CA4E4BE381A58EF21">
      <SHORT-NAME>Frames</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5C7B0D93274732AA88DF389BCFEBDC35">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="2AE807CB3B8331CF9FF12D49B1F5248A">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="886FAA92D20C38A895D8EC50A77C859F">
      <SHORT-NAME>SecureCommunicationPropsSet</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="6EE07523DBF237C5AF88652AFCDB4EF6">
      <SHORT-NAME>CommunicationClusters</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="CB161B04E0793952A86FC3289962259A">
          <SHORT-NAME>BODY3</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E4E49B6EE51E35279C2924370F77093B">
      <SHORT-NAME>NmConfigs</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="33842F0B7D04351FBDFE570259252799">
      <SHORT-NAME>ISignalIPduGroups</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="9EEAB0439C7432EA832ADFA168B2E512">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="4CE50EB0A0273B93835CCE0B093BC29C">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="F57CEA0F9BEC3F0BAB3F27BBF8BDF9CC">
      <SHORT-NAME>TpConfigs</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="85FD55E56A1B319FB60646D7549D75DE">
          <SHORT-NAME>BODY3</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0F4AD101A91037AB9D59BF9B78A11E9E">
      <SHORT-NAME>DiagnosticConnections</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="D6FB7BD71C473B11A6C802D22235B2E9">
          <SHORT-NAME>BODY3</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="D7C3886EDC0E3BC68C7FD5E576F121E3">
              <SHORT-NAME>PKG_BODY3</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="04C77B0D064E3C65838A777A28E12233">
      <SHORT-NAME>GlobalTimeDomains</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="4FB0CE39E42636E1B118FA293B4A2045">
      <SHORT-NAME>SwComponentTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE T="2021-06-10T13:06:06Z" UUID="0b9def77-0c33-495d-a337-30be6c8f0576">
      <SHORT-NAME>AUTOLIV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE T="2017-01-04T09:25:38Z" UUID="910958b0-b164-45e9-8a98-19c12e7c4124">
          <SHORT-NAME>SoftwareComponents</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="eb9e0a26-6e6f-42cf-93e1-d9e0b34ce23d">
              <SHORT-NAME>ATM</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="74abd632-ee97-47fd-bc95-1e8589760da1">
              <SHORT-NAME>BFE</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8196d051-624f-4f7d-b818-d379e7f39f22">
              <SHORT-NAME>BFS</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="650dd25c-6456-423f-b9d1-108752b24cde">
              <SHORT-NAME>BMM</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="d33acc36-f043-4f2e-860e-5155fbdefba1">
              <SHORT-NAME>BSR</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="82ea07a0-9971-4ec7-8541-d5a9e62622d1">
              <SHORT-NAME>CIL</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c2ece6c8-94d6-40b7-bae6-28c777dd7973">
              <SHORT-NAME>DIA</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="de4aaccb-7023-4197-b190-a2ec1cfc41fa">
              <SHORT-NAME>EOL</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="567f2c50-6741-4709-85d2-70be1d0571e3">
              <SHORT-NAME>ERH</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="a2f22aa9-d98b-4d3c-9db4-ea84b7a69c24">
              <SHORT-NAME>HWA</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c3da46bb-683c-41a6-b0bf-f4c0b5a08768">
              <SHORT-NAME>MMG</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6135397c-b097-4687-b1a2-b24e6345c03d">
              <SHORT-NAME>PAL</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="31a16dab-a090-4a4d-a8dd-282a3376a102">
              <SHORT-NAME>PMP</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="d8de5ccc-bdd6-4949-983c-8e97f91f7c8d">
              <SHORT-NAME>PRE</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="cceae24b-8002-4f5d-85bf-ec55eeb7a1a1">
              <SHORT-NAME>PRO</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e62c1846-7e0b-47b7-80ce-03cc810cb4a7">
              <SHORT-NAME>RCM</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2017-01-04T09:25:38Z" UUID="81552ef2-c4c5-4f81-8f04-06ea9b9b17c6">
              <SHORT-NAME>SCM</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7388a4ff-8b26-44b7-902b-0c4339586273">
              <SHORT-NAME>SFR</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE T="2021-06-09T14:10:51Z" UUID="479d67c4-2e83-4fb9-a667-752a4b1d703a">
          <SHORT-NAME>GlobalDictionary</SHORT-NAME>
          <SHORT-NAME-PATTERN />
          <AR-PACKAGES>
            <AR-PACKAGE UUID="c21c8e69-4aae-45b1-b8ba-36bbc7981767">
              <SHORT-NAME>Constants</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2de646df-afd1-431b-bcf5-38755668c432">
              <SHORT-NAME>ApplicationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2018-06-14T15:31:24Z" UUID="b2b7c181-47bf-4097-bd9a-fc78b7e94b19">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2021-06-15T11:39:15Z" UUID="6c32dd57-251f-471a-9df6-50caea98070c">
              <SHORT-NAME>DataConstraints</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2021-05-19T15:36:31Z" UUID="eeb80edd-821c-43fe-812b-6c36b6990e88">
              <SHORT-NAME>DataTypeMappingSet</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="dd69deac-340d-4dea-8d0f-e1e3b4b2176f">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2020-11-04T15:08:11Z" UUID="3d7941ee-4e87-44ce-a3ab-9d61f24fdcd8">
              <SHORT-NAME>ClientServerInterfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c180ec4a-8860-4264-a3f9-85af975b371e">
              <SHORT-NAME>SenderReceiverInterfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="e6e54a7e-582a-4e19-a6bf-382dfb6b4998">
              <SHORT-NAME>BaseTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2cd09733-d1d2-412a-9c2c-a4d34a4cca21">
              <SHORT-NAME>ModeSwithInterfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE T="2016-06-03T09:50:28Z" UUID="d72398c6-29cd-4337-bf5a-2730fc3b369b">
              <SHORT-NAME>SwAddrMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="33fefe4e-ac28-44d5-8547-cdf0adc2fe40">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7661CC50-8657-4892-B834-2807157801F9">
      <SHORT-NAME>ComponentTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="5541CEFA-A1DE-4F65-ABEF-121D3043AE56">
          <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C8356DA7-1FED-4098-9523-E6B912DA4614">
          <SHORT-NAME>ConstantMappingSets</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BF49836D-9B09-4B38-A95A-87664ECFB6DD">
      <SHORT-NAME>SecurityArchitecture</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="571E6FA6-7B7B-481B-B021-8C4C893ECF39">
          <SHORT-NAME>Constants</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3C46045F-2B6B-49F4-9218-9DA34D15029F">
          <SHORT-NAME>ComponentTypes</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="E2C628A9-3C4B-48A0-A20F-BF054A2D7179">
              <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="9E8B09B1-A55F-4F9D-B57A-D65D47379D04">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="57DCFCAB-3626-4A5B-A0B2-7535AA5BCE19">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D9D58B5F-DF3C-40BB-8CC4-18119DAD2C6B">
          <SHORT-NAME>DataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B6D059CE-C3B1-4952-AD2A-EE7A389B7D3D">
          <SHORT-NAME>external</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="03D2145D-0E46-4EAB-8438-C5285AEF2164">
              <SHORT-NAME>Csm_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F29A8B46-5AB1-4EFD-AFC6-DDC0F4D414A9">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="3FDD7A7A-0FE0-4475-8F10-56A05712F73B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="83638E41-CF6A-4DE0-88B0-A5F435354D7E">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="2F5DBD0F-D41F-473A-B7D5-15D31BD71CAE">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="38C8801A-0660-4014-A3F9-850DDC7EC6CA">
              <SHORT-NAME>Dcm_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="8B7C11EF-BF0F-4CE8-AE43-35A57FBB1AA0">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="827E25A5-D621-4A0E-A8D4-806C746B6EEF">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="B2369055-C2BC-458F-B55F-97A87D1FB555">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="38CFCC9F-2BF4-4705-BCBD-2FD7E340F2EE">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="0BC49195-8964-4C11-B9B0-8178DF9EFADB">
              <SHORT-NAME>SecOC_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F4282FB6-C9EC-4823-96AD-40F4E1862310">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="AB201A0D-E117-4707-AA4E-5A65CE2AE0FC">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="6635FBDC-11E9-4894-92C0-8D296F6BA304">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="0E5BBFD0-BBD2-4CE9-A5B5-ABE93632A273">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="2179E14E-8806-4CAC-A32C-25C6AD6FC30E">
              <SHORT-NAME>Ssa_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="72F22C1B-DBE9-4E23-ADC3-B31B6A9244D6">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3F2C2849-9B99-47F6-BAC7-F16B56A058F9">
              <SHORT-NAME>Dem_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="CC9CF3FB-16CC-4778-9CCC-B7D63BDDC875">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="D0EB8DD9-AA06-4F07-B1CB-C0C5F247D399">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="40A1FD8D-545F-4A7C-B056-F48D9401184C">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="150A6226-EC3D-4C36-9D93-780EC82FD51D">
              <SHORT-NAME>NvM_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="7EF7B3CA-7680-45CE-9241-9CCC6B0D360B">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="57889C15-3C0A-4FD2-9AFA-A0FC146B3150">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="838F08F0-7806-49BB-96FB-5A66233C2285">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="D8B04C8F-C4F9-4C14-9D88-569A791E607D">
              <SHORT-NAME>KeyM_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="4EB01508-FC0B-4029-9BBB-9A0F9329CB04">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="E8CD6798-40FD-4576-8794-FC0A1CECAD55">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="A03E57AE-F164-446D-BB38-B19E46B802EA">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7A126040-75F6-46A5-B80F-5B54C11116E0">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8FC6D116-0B8B-4013-8F52-BA27CEC7E3BF">
          <SHORT-NAME>extSwc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="CE8CFE69-861C-4CC3-B6EE-C974DA02E7C2">
              <SHORT-NAME>Csm_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="B9BBE488-B2EE-4A24-A86D-171A4711AC42">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="21A1D937-B4F4-425D-BB80-97EEB2A3FFEB">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="7DEE5007-E973-4FAC-B724-1A645A7CFD5B">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="CED59984-A75C-43CF-AB7C-FE94CB1DD1FE">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="4050BF7E-1C90-47B2-BC27-DEDC5AF614AA">
              <SHORT-NAME>Dcm_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="2D5F5A08-52D4-4AAD-95C2-9F63E7D6BBC6">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="476A83B3-3A55-4A20-A31B-C0A18BDF7922">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="F56A0828-E51B-4CCC-83B2-A5B45A851127">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="E1F4FE06-2CBC-401D-A98C-FB3DD545AB2E">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E2D45442-D71D-45F0-8A6E-4ED8A6E9DD99">
              <SHORT-NAME>Dem_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="140101BD-F725-442A-8B4F-98BC4D90A115">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="9BB7DDCE-A1F5-4073-8328-330E76955E75">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C1646AA9-27E3-4B92-8B46-32AD2FAFB618">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="C94F3BC4-67DF-49CB-B6FC-73E6FDA273CF">
              <SHORT-NAME>NvM_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="F5E96B5B-0DE7-429A-8077-B814C7CB51B0">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="A43164D0-724A-4D9D-AF1C-9562C67AE8DC">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="EFDE5984-6041-4BA1-9A6A-4E63EB4B72ED">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="07C96D78-DCE5-448C-98CF-E4AAD9AB3225">
              <SHORT-NAME>KeyM_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="45F59FFD-40F1-4B99-AB9D-352A18EF4D54">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="11344CC3-87E7-400A-8756-25CBD2B70598">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="C1D96D64-E548-4BC4-8991-66F216E81217">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="790B3A78-5500-4E94-AC21-B9DEFFF9BCD3">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="8EFF504C-5B61-451B-ACEA-964B2F6D21F4">
              <SHORT-NAME>SecOC_swc</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="633591C5-7EFD-4F43-A474-48F653149B24">
                  <SHORT-NAME>DataTypes</SHORT-NAME>
                  <AR-PACKAGES>
                    <AR-PACKAGE UUID="6D7A1936-8CBA-47F5-AC0B-B1349038AB0B">
                      <SHORT-NAME>DataConstrs</SHORT-NAME>
                    </AR-PACKAGE>
                    <AR-PACKAGE UUID="0D922214-35E3-4901-B0BB-0173E00DE66D">
                      <SHORT-NAME>CompuMethods</SHORT-NAME>
                    </AR-PACKAGE>
                  </AR-PACKAGES>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C7A6DB92-B443-4DD0-9679-5853A30DDB4E">
                  <SHORT-NAME>Interfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="DFFDBAE1-7B9A-4307-930A-EA64DB4FB54D">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="5D378EEB-B10F-4C03-A7A3-FC246C559F20">
          <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E9060BA123D73C0D93AA107E78FCDDCE">
      <SHORT-NAME>Constants</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E3F1194A-7256-48A6-B228-C691F7D2EBE1">
      <SHORT-NAME>Daimler</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="3A5C0BF1-3174-45AB-8B17-73977F284EEB">
          <SHORT-NAME>SwcDiag</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="C62648BE-234F-433A-8F03-D981DC229B2D">
              <SHORT-NAME>ConstantSpecifications</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="E843FA81-458F-46F7-8198-DA48700F7D8D">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="46249C37-6869-4246-BCE3-7F4C6F072C9E">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5DA36F93-9871-4D8A-8435-CAB7DEA5DC12">
              <SHORT-NAME>PortInterfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="277CD3D3-94EC-4319-9F14-CC98DA3136A5">
              <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="C151959B-5814-4A9E-AB88-A5AC17F5DE3B">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="046448B6-57E3-4294-A8F8-0C63965A1149">
              <SHORT-NAME>Dcm</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="D47397F6-0BD0-46DE-BA29-6DA9A881AC11">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F5A3EE53-8F26-49B2-967A-E30E5B43E563">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="9E5362CE-868E-480B-B2B4-B78D730BC62D">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="3BDCBD11-BD0E-439B-8D58-9EEDA771A796">
              <SHORT-NAME>Dem</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="41FBF2AD-2A4F-40E5-8015-13E42F134787">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="F7F84C90-239B-4578-8575-52F13879FDAD">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="6A7ADE0E-0664-4404-97D5-7010DEE4515E">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="77CD6F5A-3E75-44BD-AC7F-7635509DAF1D">
              <SHORT-NAME>StbM</SHORT-NAME>
              <AR-PACKAGES>
                <AR-PACKAGE UUID="42E90DD9-6B05-4115-B6FC-3F4CC9FB1EF9">
                  <SHORT-NAME>CompuMethods</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="7F21017F-DBBE-4547-BC04-F208C5A7C4F2">
                  <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
                </AR-PACKAGE>
                <AR-PACKAGE UUID="C825485E-2997-4459-AEAE-D2F6B3130BD8">
                  <SHORT-NAME>PortInterfaces</SHORT-NAME>
                </AR-PACKAGE>
              </AR-PACKAGES>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="0E5D2EC2-83A4-4195-A97E-A638D6753237">
      <SHORT-NAME>Predefined_DEV</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="B9000A2F-6AA2-40E0-B848-756D5F4E3602">
          <SHORT-NAME>DataConstraints</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="39789D78-393D-465A-A152-A0C769A882D4">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8F6DD6A8-37A4-4011-8739-AE4F13D75C5C">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="A8628A4D-35FB-4AE9-8CED-DF81D8CB4BF0">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FC104A249F3232C88586B63381A5F13A">
      <SHORT-NAME>Units</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="11A10FF355CD3521A3E8D76C9AD81956">
      <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B416D8A9DE1D3555BA640F75A944CAB3">
      <SHORT-NAME>DataConstraints</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="420A919AACA1370BA6E3132BAF0D2B8F">
      <SHORT-NAME>ApplicationDataTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="7F5E622BAFA13E70B37B35BBF34506D6">
      <SHORT-NAME>CompuMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="3D0EE9107C1939519D998A771EA991D8">
      <SHORT-NAME>DataTypeMappingSets</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="088C61DD-909F-47EF-B9B6-742A5F14E2C1">
      <SHORT-NAME>DataTypes</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="906B7D0E-4C09-4DA4-BD66-FB7BF332FC2E">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="20872DC4-A771-4C97-ADB6-9CD178E1238D">
          <SHORT-NAME>BaseTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="B99F8FD2-38CD-4D6C-A8F9-DC12A0163334">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="30C9FE5D-D4C7-4C1F-8EA9-6FAA4D8476C8">
          <SHORT-NAME>Units</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="25d8d45b-5a12-48f0-96c8-315f83008b1d">
      <SHORT-NAME>AUTOSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="df56ca92-8af3-408f-84c1-db0364fc738d">
          <SHORT-NAME>AISpecification</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="225e7a13-ff6a-320e-ad5c-1ce6311d05c4">
              <SHORT-NAME>Units</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="c37a83ca-b70e-345c-94e6-c323262cb767">
              <SHORT-NAME>PhysicalDimensions</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="FF8ED48F-62AB-4F66-B97A-E3A23D252124">
          <SHORT-NAME>Platform</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="603F9D35-1760-4ABB-B588-DB5BCDE511A5">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="50281195-C0F6-40CD-81F7-F103388F37B4">
      <SHORT-NAME>AUTOSAR_Dem</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4CB3BA41-E751-4891-99F7-D2271C385F48">
          <SHORT-NAME>ASR42</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="116C6A37-DD8C-4A7C-B570-6822BF8E3425">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="7F3BE8F8-B0FB-4556-9851-9340402B52BA">
              <SHORT-NAME>DataConstrs</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="465669F4-1B06-4FE9-935B-F7005C9E6E1E">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="F6B95B8B-2EBA-49D0-B560-623817DD026C">
              <SHORT-NAME>PortInterfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="387B3591-6CF6-4597-9085-54B569FC7855">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="8EF4B8D3-7207-49CB-AE2C-DA3D81442D3D">
          <SHORT-NAME>DataConstrs</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="6B36494E-1912-44D4-A117-6AE6A54D09A1">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="3A3CD85D-DEAE-4CE8-8564-192B25F5D681">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="65F63174-1FA7-4137-8825-17494D7E5D77">
      <SHORT-NAME>AUTOSAR_NvM</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="80701571-5105-4B12-B59F-8D0C50B0FE5F">
          <SHORT-NAME>ASR42</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="F7DE77AD-3341-402D-82D5-C3C08EE02D3D">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="CC935F2D-3E07-4BBD-AD2B-E525648DCA4F">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="5AEE8E68-9F49-406A-8E2F-3A52CF66DD20">
              <SHORT-NAME>PortInterfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="D5B47C25-9C02-4328-9830-D6F64A1662DD">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="830EB2DD-E236-418C-BAF1-4808D90807B4">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="52CB7EC0-6D62-4309-B1DC-E4F99015C032">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="626a01f5-0000-52e6-fe4c-52e68a873a2b">
      <SHORT-NAME>Constraints</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DD1B051F-3131-4711-9427-4F24EA38BD5F">
      <SHORT-NAME>AUTOSAR_Dcm</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="4EF7AC47-259F-408C-BBC8-5953AEE6007D">
          <SHORT-NAME>ASR42</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="AB5B0EEF-BDA0-432E-B3EE-3E9793909F69">
              <SHORT-NAME>CompuMethods</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="82779CA7-A0CE-4D79-AC98-1E80FC4A57DF">
              <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6AACF790-CA26-4F90-8C52-2FE86521EFDF">
              <SHORT-NAME>PortInterfaces</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="715E6FA1-62ED-4F1A-947D-B7C7593E3756">
          <SHORT-NAME>CompuMethods</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="2D0F9CB3-FFB8-48D5-BCE7-6AF83FEC07AD">
          <SHORT-NAME>ImplementationDataTypes</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="32C018E5-ED4E-4E5C-A7D1-784412F2E4DF">
          <SHORT-NAME>PortInterfaces</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="E361EE64-86C4-4220-B6BE-03295F7140FC">
      <SHORT-NAME>ECUCompositionTypes</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C8672E9A-1B3E-4E51-A47A-23A8F8FFFF36">
      <SHORT-NAME>EndToEndProtections</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="626a01f5-0000-70e8-b3dc-70e8126ce559">
      <SHORT-NAME>BaseType</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="626a01f5-0000-fe03-60c0-fe03c3515833">
      <SHORT-NAME>Semantics</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="064793E6-BA4B-45FF-BEB8-69E3C3DA47EF">
      <SHORT-NAME>ECUCompositions</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="D3CC6631-9B7B-4882-A3C1-D494C67D03DC">
      <SHORT-NAME>ModeDclrGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="315559FDA47F3EA786B59B3AB3121F87">
      <SHORT-NAME>PortInterfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="FF402C23-07B1-488B-A47D-C84F81565360">
      <SHORT-NAME>SwAddrMethods</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9D06A84E-C67A-4C67-99E6-539E9A9475D8">
      <SHORT-NAME>Blueprints</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="564993AF-35E6-4549-90FF-F143DE70C58C">
          <SHORT-NAME>BlueprintMappingSets</SHORT-NAME>
        </AR-PACKAGE>
        <AR-PACKAGE UUID="0C61DB36-5866-4A1D-AEE0-16F215859818">
          <SHORT-NAME>PortPrototypeBlueprints</SHORT-NAME>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C36AA4C70B2F3DD09B6F87A52B2C95A0">
      <SHORT-NAME>ModeDeclarationGroups</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="626a01f5-0000-b356-3a26-b356313f9799">
      <SHORT-NAME>Interfaces</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B9F26D75-76A3-46DA-92EA-2FE46905BCF4">
      <SHORT-NAME>AUTOSAR_Base</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="986B8188-AD65-4F39-ADFB-D306D7349643">
      <SHORT-NAME>AUTOSAR_Can</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="9D31C018-5227-49CB-9CD0-E729208D5FD6">
      <SHORT-NAME>AUTOSAR_CanTrcv</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="065CDDD3-E961-4D6D-A1E1-8BF8EA77F992">
      <SHORT-NAME>AUTOSAR_ComStack_Types</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="82481D39-85E5-4C77-A59A-CEDE278178BB">
      <SHORT-NAME>AUTOSAR_Comtype</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="956BCF08-73A2-4A20-A7A5-A1B91BCC8B3E">
      <SHORT-NAME>AUTOSAR_GenDef</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="DE3779A2-D482-4EAF-9D47-D879564043DA">
      <SHORT-NAME>AUTOSAR_MemMap</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="A1D2412C-0612-4D76-B38B-38F76D8918B7">
      <SHORT-NAME>AUTOSAR_Std</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="BF63344A-08B8-4619-9EB8-8F40F8EDE180">
      <SHORT-NAME>EB_Base</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="B550BA74E85B3C71A5ABF5CF08EB7376">
      <SHORT-NAME>CryptoPrimitives</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="729103C139F231A2ABD341D97E22A34F">
      <SHORT-NAME>CryptoDevelopmentKeys</SHORT-NAME>
    </AR-PACKAGE>
    <AR-PACKAGE UUID="C42DA385CE253AB6BB5B6BDF12F51E0C">
      <SHORT-NAME>E2EProfileCompatibilityPropsCollection</SHORT-NAME>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>